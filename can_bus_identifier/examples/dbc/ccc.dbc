VERSION ""
NS_ :
BS_:

BU_: ECUC ECUX

BO_ 100 Msg100: 8 ECUX
BO_ 345 Msg345: 8 ECUX